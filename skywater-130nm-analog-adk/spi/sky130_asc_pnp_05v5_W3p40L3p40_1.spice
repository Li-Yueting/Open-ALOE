* NGSPICE file created from sky130_asc_pnp_05v5_W3p40L3p40_1.ext - technology: sky130A

.subckt sky130_asc_pnp_05v5_W3p40L3p40_1 Emitter Base Collector VPWR VGND
X0 Collector Base Emitter sky130_fd_pr__pnp_05v5_W3p40L3p40
.ends
